## scripts/demo/Kconfig.demo
```kconfig
config DEMO_FEATURE
	bool "enable demo"
	default y

config demo_timeout
  int "timeout"
  default 5000
```
